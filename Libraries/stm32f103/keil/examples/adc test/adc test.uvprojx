# Keil uVision project adc test.uvprojx, settings and files
target adc test (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uart +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --cpp
  c include: ..\adc test;.\CMSIS\inc;.\code\inc;..\..\..\periph library\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group code
    ./code/src/: main.cpp
  group lib
    ../../../periph library/src/: stm32f103_sysFunc.cpp stm32f103_UART.cpp stm32f103_pin.cpp stm32f103_adc_mod.cpp stm32f103_SPI.c
  group CMSIS
    ./CMSIS/src/: core_cm3.c
    ../../../periph library/inc/: system_stm32f10x.c
  group startup
    ./startup/: startup_stm32f10x_md.s
