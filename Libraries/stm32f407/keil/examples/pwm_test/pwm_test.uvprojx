# Keil uVision project pwm_test.uvprojx, settings and files
target pwm test (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pin_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --cpp
  c include: ..\..\..\periph_library\inc;.\CMSIS\inc;.\code\inc;..\pin_test
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./CMSIS/src/: system_stm32f4xx.c
  group code
    ./code/src/: main.cpp
  group startup
    ./startup/: startup_stm32f40xx.s
  group periph library
    ../../../periph_library/src/: stm32f407_pin.cpp stm32f407_sysFunc.cpp stm32f407_UART.cpp stm32f407_PWM.cpp
