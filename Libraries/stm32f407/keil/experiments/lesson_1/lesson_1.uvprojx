# Keil uVision project lesson_1.uvprojx, settings and files
target lesson_1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lesson_1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --cpp
  c include: .\CMSIS\inc;.\Code\inc;..\lesson_1;..\..\..\periph_library\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./Startup/: startup_stm32f40xx.s
  group CMSIS
    ./CMSIS/src/: system_stm32f4xx.c
  group Code
    ./Code/src/: main.cpp
