# Keil uVision project Mother board.uvprojx, settings and files
target Mother board (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mother board v2 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=6 wLevel=2
  c misc: --cpp
  c include: ..\..\Libraries\stm32f407\periph_library\inc;.\CMSIS\inc;.\code\inc;..\Mother board;..\..\Libraries\mpu9250\inc;.\code\src\libs\FunctionalClass;.\code\src\libs\Obstacle;.\code\src\libs\Robot;.\code\src\libs\RobotParametrs;.\code\src\libs\CameraObject;.\code\src\libs\VecField;.\code\src\libs\VectorToMove;..\..\Libraries\SSD1306\inc;.\code\src\libs\FieldObject
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./CMSIS/src/: system_stm32f4xx.c
  group code
    ./code/src/: main.cpp goalkeeper.cpp
    ./code/src/libs/FunctionalClass/: FunctionalClass.cpp
    ./code/inc/: Strategy.h trajectory.h
  group startup
    ./startup/: startup_stm32f40xx.s
  group periph library
    ../../Libraries/stm32f407/periph_library/src/: stm32f407_pin.cpp stm32f407_adc.cpp stm32f407_PWM.cpp stm32f407_SPI.cpp stm32f407_sysFunc.cpp stm32f407_UART.cpp
    ../../Libraries/SSD1306/src/: SSD1306.cpp
    ../../Libraries/mpu9250/src/: mpu9250.cpp
