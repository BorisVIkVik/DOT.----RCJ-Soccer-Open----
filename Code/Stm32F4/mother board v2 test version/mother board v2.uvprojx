# Keil uVision project mother board v2.uvprojx, settings and files
target mother board v2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mother board v2 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=6 wLevel=2
  c misc: --cpp
  c include: ..\..\stm32\stm32f407\periph_library\inc;.\CMSIS\inc;.\code\inc;..\mother board v2;..\..\mpu9250;.\code\src\Write_Robot_Code\FunctionalClass;.\code\src\Write_Robot_Code\Obstacle;.\code\src\Write_Robot_Code\Robot;.\code\src\Write_Robot_Code\RobotParametrs;.\code\src\Write_Robot_Code\StructObject;.\code\src\Write_Robot_Code\VecField;.\code\src\Write_Robot_Code\VectorToMove
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./CMSIS/src/: system_stm32f4xx.c
  group code
    ./code/src/: main.cpp
    ./code/src/Write_Robot_Code/FunctionalClass/: FunctionalClass.cpp
  group startup
    ./startup/: startup_stm32f40xx.s
  group periph library
    ../../stm32/stm32f407/periph_library/src/: stm32f407_pin.cpp stm32f407_SPI.cpp stm32f407_SSD1306.cpp stm32f407_sysFunc.cpp stm32f407_UART.cpp stm32f407_adc.cpp stm32f407_PWM.cpp
    ../../mpu9250/: mpu9250.cpp
